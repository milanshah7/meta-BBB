SUMMARY = "Custom image for beaglebone on core-image-minimal"

LICENSE = "MIT"

inherit core-image
