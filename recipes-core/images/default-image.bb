require recipes-core/images/beaglebone-image-minimal.bb
export IMAGE_BASENAME = "default-image"
